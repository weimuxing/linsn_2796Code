# Keil uVision project STD_FW_MtP.uvproj, settings and files
target RL6193_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6193_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6193_PROJECT, _SCALER_TYPE = _RL6193_SERIES
  c include: .\Output\RL6193;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\RL6193_Series_Scaler\Header;.\Kernel\Scaler\RL6193_Series_Scaler\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header;.\User\user
  asm misc: DEFINE(_PROJECT=_RL6193_PROJECT,_SCALER_TYPE=_RL6193_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
  link misc: COMMON(?PR?SCALERTIMERINTPROC?SCALERTIMERFUNCTION)
BANK0(?CO?SYSSOURCE, ?CO?SYSPOWER, ?CO?SCALERSYNC, ?CO?SCALERMDOMAIN, ?CO?USERCOMMONMODESEARCH, ?CO?RL6001_SERIES_PLL, ?CO?RL6001_SERIES_AUTOFUNC, ?CO?RL6001_SERIES_TMDS)
BANK1(?CO?SCALERCOLOR, ?CO?RL6001_SERIES_COLOR)
BANK2(?CO?USERCOMMONDDCCIFUNCTION, ?CO?USERCOMMONEEPROMSYSTEM, ?CO?RTD2011USERADJUST, ?CO?RTD2011OSDFONT, ?CO?RTD2011OSDTABLE, ?CO?RTD2011OSDTABLEFUNC)
BANK3(?CO?RTD2011OSDACTIONFLOW, ?CO?RTD2011OSDDISPLAY, ?CO?RTD2011DDCCI, ?CO?RTD2011EEPROMOSD, ?CO?RTDFactoryFunction, ?CO?RTDFactoryMode)
  group Project
    ./Project/Header/: User_Project_List.h User_Project_Include.h User_Project_Option.h User_Scaler_Option.h RL6193_Project.h RL6410_Project.h
  group Pcb
    ./Pcb/: User_Pcb_List.h User_Pcb_Include.h User_Pcb_Option.h RL6193_QA_A_1A1H4MHL1DP1mDP_DPTX_LVDS_VB1.h RL6193_QA_B_1A1H4MHL1DP_DPTX_LVDS_eDP.h RL6193_DEMO_A_1A1H4MHL1DP_DPTX_LVDS_eDP.h RL6193_DEMO_B_1A2MHL1DP1mDP1DUALDVI_DPTX_LVDS_eDP.h RL6193_DEMO_C_1A3MHL1DP_DPTX_LVDS_VB1.h RL6193_DEMO_D_1A1H4MHL1DP_DPTX_LVDS_VB1.h RL6193_DEMO_E_1H4MHL1DP1mDP_DPTX_LVDS_VB1.h RL6410_QA_A_1A4MHL1DP1mDP_DPTX_LVDS_eDP.h RL6410_QA_B_1A6mDP_DPTX_LVDS_eDP.h RL6410_DEMO_A_1A4MHL2DP_DPTX_LVDS_eDP.h RL6410_DEMO_B_1A4MHL1DP1mDP_DPTX_LVDS_eDP.h RL6410_DEMO_C_1A2MHL1DP1mDP1DUALDVI_DPTX_LVDS_eDP.h RL6410_DEMO_D_1A4MHL1DP1mDP_DPTX_LVDS_VB1.h RL6410_DEMO_TC_3MHL1DP1TYPEC_DPTX_LVDS_eDP.h RL6410_DEMO_5K3K_2H2DP_LVDS_eDP.h RL6410_DEMO_E_1A4MHL2DP_DPTX_LVDS_VB1.h
    ./Pcb/EXAMPLE/: RL6193_PCB_EXAMPLE.h RL6410_PCB_EXAMPLE.h
  group Panel
    ./Panel/: User_Panel_List.h User_Panel_Include.h User_Panel_Option.h 00_CMO_LVDS_17.h 01_CMO_LVDS_19_WXGA.h 02_AU_LVDS_21_5_WUXGA.h 03_AU_LVDS_27_WUXGA_FREESYNC.h 04_MULTIPANEL_LVDS_21_5_WUXGA.h 05_AU_LVDS_22_WSXGA.h 06_AU_LVDS_22_WSXGA_QC.h 07_AU_LVDS_23_WUXGA.h 08_AU_LVDS_24_WUXGA.h 09_AU_DP_21_5_WUXGA.h 10_LG_LED_DP_27_UHD.h 14_LG_LED_LVDS_27_WUXGA.h 15_SAMSUNG_LED_DP_15_6_UHD.h 16_AUO_LED_DP_32_UHD.h 17_SAMSUNG_LED_DP_23_6_UHD.h 18_INNOLUX_LED_VBO_28_UHD.h 19_LG_LED_LVDS_23_UHD.h 20_INNOLUX_LED_VBO_40_UHD.h 21_AU_LVDS_21_5_WUXGA_FREESYNC.h 22_LG_LED_DP_27_QQHD.h 23_LG_LED_DP_27_QHD.h 24_LG_LED_DP_27_QHD_QC.h 25_AU_DP_21_5_WUXGA_FREESYNC.h 26_INNOLUX_TTL_7.h 27_MULTIPANEL_DP_21_5_WUXGA.h
    ./Panel/EXAMPLE/: PANEL_LVDS_EXAMPLE.h PANEL_DPTX_EXAMPLE.h PANEL_VBO_EXAMPLE.h
  group Common
    ./Kernel/Common/: reg52_RTD.h L51_bank.a51 STARTUP.a51 Debug.h Global.h Project.h Scaler_Test_Function.h RL6193_Gen_Option.h RL6193_Project_Default.h RL6193_Pcb_Default.h RL6410_Gen_Option.h RL6410_Project_Default.h RL6410_Pcb_Default.h
  group System
    ./Kernel/System/Header/: SysInterface.h SysInclude.h
    ./Kernel/System/Code/: SysInt.c SysJudge.c SysMain.c SysMHL.c SysMode.c SysPower.c SysRegion.c SysSource.c SysTimer.c SysVGA.c SysAudio.c SysDP.c SysTMDS.c
  group ScalerFunction
    ./Kernel/Scaler/ScalerFunction/Header/: ScalerFunctionCommonInclude.h ScalerFunctionInclude.h ScalerFunctionInterface.h
    ./Kernel/Scaler/ScalerFunction/Code/: ScalerADC.c ScalerAudio.c ScalerAutoFunc.c ScalerColor.c ScalerDDomain.c ScalerDDR.c ScalerDebug.c ScalerDisplay.c ScalerDisplayDPTx.c ScalerDP.c ScalerDPRx0.c ScalerDPRx0HDCP2.c ScalerDPRx1.c ScalerDPRx1HDCP2.c ScalerDPRxMST.c ScalerDPTx.c ScalerDPTxAux.c ScalerDPTxMST.c ScalerFRC.c ScalerFormatConversion.c ScalerGDIPhy.c ScalerGDIPhyTx.c ScalerGlobal.c ScalerHDCP2.c ScalerIOSC.c ScalerIDomain.c ScalerIR.c ScalerLDO.c ScalerMcu.c ScalerMDomain.c ScalerMeasure.c ScalerMemory.c ScalerMHLRx0.c ScalerMHLRx1.c ScalerMHLRx2.c ScalerMHLRx3.c ScalerMHLRx4.c ScalerMHLRx5.c ScalerNVRam.c ScalerOD.c ScalerOsd.c ScalerPinshare.c ScalerPLL.c ScalerPower.c ScalerReg.c ScalerRegion.c ScalerRotation.c ScalerScaling.c ScalerSync.c ScalerSyncProc.c ScalerTCON.c ScalerTimerFunction.c ScalerTMDSRx0.c ScalerTMDSRx1.c ScalerTMDSRx2.c ScalerTMDSRx3.c ScalerTMDSRx4.c ScalerTMDSRx5.c ScalerVGATop.c ScalerVGIP.c Scalers.LIB
  group RL6193_Series_Scaler
    ./Kernel/Scaler/RL6193_Series_Scaler/Lib/Output/: RL6193_FunctionLib.LIB
    ./Kernel/Scaler/RL6193_Series_Scaler/Header/: RL6193_Series_FunctionCommonInclude.h RL6193_Series_FunctionInclude.h RL6193_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6193_Series_Scaler/Code/: RL6193_Series_ADC.c RL6193_Series_Audio.c RL6193_Series_Color.c RL6193_Series_DDR.c RL6193_Series_Display.c RL6193_Series_DisplayDPTx.c RL6193_Series_DP.c RL6193_Series_DPRx0.c RL6193_Series_DPRx1.c RL6193_Series_DPRxMST.c RL6193_Series_DPTx.c RL6193_Series_DPTxMST.c RL6193_Series_FRC.c RL6193_Series_FormatConversion.c RL6193_Series_GDIPhy.c RL6193_Series_Global.c RL6193_Series_Mcu.c RL6193_Series_MDomain.c RL6193_Series_Measure.c RL6193_Series_Memory.c RL6193_Series_MHL.c RL6193_Series_MHLRx0.c RL6193_Series_MHLRx1.c RL6193_Series_MHLRx2.c RL6193_Series_MHLRx3.c RL6193_Series_MHLRx4.c RL6193_Series_MHLRx5.c RL6193_Series_OD.c RL6193_Series_Osd.c RL6193_Series_Pinshare.c RL6193_Series_PLL.c RL6193_Series_Reg.c RL6193_Series_Power.c RL6193_Series_Scaling.c RL6193_Series_Sync.c RL6193_Series_TMDSRx2.c RL6193_Series_TMDSRx3.c RL6193_Series_TMDSRx4.c RL6193_Series_TMDSRx5.c RL6193_Series_TMDS.c RL6193_Series_VGATop.c RL6193_Series_VGIP.c RL6193_Series_DPRx0_INT.c RL6193_Series_DPRx1_INT.c RL6193_Series_DP_INT.c
  group RL6410_Series_Scaler
    ./Kernel/Scaler/RL6410_Series_Scaler/Lib/Output/: RL6410_FunctionLib.LIB
    ./Kernel/Scaler/RL6410_Series_Scaler/Header/: RL6410_Series_FunctionCommonInclude.h RL6410_Series_FunctionInclude.h RL6410_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6410_Series_Scaler/Code/: RL6410_Series_ADC.c RL6410_Series_Audio.c RL6410_Series_Color.c RL6410_Series_DDR.c RL6410_Series_Display.c RL6410_Series_DisplayDPTx.c RL6410_Series_DP.c RL6410_Series_DPRx0.c RL6410_Series_DPRx1.c RL6410_Series_DPRxMST.c RL6410_Series_DPTx.c RL6410_Series_DPTxMST.c RL6410_Series_FormatConversion.c RL6410_Series_FRC.c RL6410_Series_GDIPhy.c RL6410_Series_Global.c RL6410_Series_HDCP2.c RL6410_Series_Mcu.c RL6410_Series_MDomain.c RL6410_Series_Measure.c RL6410_Series_Memory.c RL6410_Series_MHL.c RL6410_Series_MHLRx2.c RL6410_Series_MHLRx3.c RL6410_Series_MHLRx4.c RL6410_Series_MHLRx5.c RL6410_Series_MHL3.c RL6410_Series_MHL3Rx2.c RL6410_Series_MHL3Rx3.c RL6410_Series_MHL3Rx4.c RL6410_Series_MHL3Rx5.c RL6410_Series_OD.c RL6410_Series_Osd.c RL6410_Series_Pinshare.c RL6410_Series_PLL.c RL6410_Series_Power.c RL6410_Series_Reg.c RL6410_Series_Scaling.c RL6410_Series_Sync.c RL6410_Series_TMDS.c RL6410_Series_TMDSRx2.c RL6410_Series_TMDSRx2HDCP2.c RL6410_Series_TMDSRx3.c RL6410_Series_TMDSRx3HDCP2.c RL6410_Series_TMDSRx4.c RL6410_Series_TMDSRx4HDCP2.c RL6410_Series_TMDSRx5.c RL6410_Series_TMDSRx5HDCP2.c RL6410_Series_VGATop.c RL6410_Series_VGIP.c RL6410_Series_DPRx0_INT.c RL6410_Series_DPRx1_INT.c RL6410_Series_DP_INT.c
  group UserCommonFunction
    ./Kernel/User Common Function/Header/: UserCommonInclude.h UserCommonInterface.h UserCommonDdcciDefine.h
    ./Kernel/User Common Function/Code/: UserCommonAdjust.c UserCommonAuto.c UserCommonDdcciFunction.c UserCommonDisplayCalibration.c UserCommonInterface.c UserCommonModeSearch.c UserCommonNVRamSystem.c UserCommonPortControllerEmbedded.c UserCommonPortControllerRts5400.c UserCommonPortControllerUser.c UserCommonTypecCommunication.c UserCommonUsbHubUser.c UserCommonUsbHubRts5411.c
  group RTD2014Function
    ./User/RTD Series/RTD2014Function/Header/: RTD2014UserInclude.h RTD2014UserModeTable.h
    ./User/RTD Series/RTD2014Function/Code/: RTD2014UserInterface.c RTD2014UserAdjust.c RTD2014UserAdjust3DGamma.c RTD2014UserAdjustOutputGamma.c RTD2014UserAdjustRGBGamma.c RTD2014UserAdjustUniformity.c RTD2014UserBoot.c RTD2014UserTypeCInterface.c
  group RTD2014Osd
    ./User/RTD Series/RTD2014Osd/Header/: RTD2014Include.h RTD2014TimerInclude.h RTD2014TimerEventIDUser.h RTD2014Project.h RTD2014NVRamOsd.h
    ./User/RTD Series/RTD2014Osd/Code/: RTD2014NVRamOsd.c RTD2014Ddcci.c RTD2014Key.c RTD2014Osd.c RTD2014OsdDisplay.c RTD2014OsdFontProp.c RTD2014OsdFontTable.c RTD2014OsdFontVLC.c RTD2014OsdFunc.c RTD2014OsdPalette.c RTD2014OsdWindow.c RTD2014OsdFontDynamicIcon_1.c RTD2014OsdFontDynamicIcon_2.c
  group RTDFactory
    ./User/RTD Factory/Header/: RTDFactoryInclude.h
    ./User/RTD Factory/Code/: RTDFactoryFunction.c RTDFactoryMode.c
  group user
    ./User/user/: pipe.c rs232command.c VideoFormatTable.c
target RL6410_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6410_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L !P "" "$K"
  AfterMake: ".\Tool\build\link.bat" "$K" !P @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6410_PROJECT, _SCALER_TYPE = _RL6410_SERIES
  c include: .\Output\RL6410;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\RL6410_Series_Scaler\Header;.\Kernel\Scaler\RL6410_Series_Scaler\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header
  asm misc: DEFINE(_PROJECT=_RL6410_PROJECT,_SCALER_TYPE=_RL6410_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
  link misc: as above
